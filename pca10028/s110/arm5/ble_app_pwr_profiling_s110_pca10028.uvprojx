# Keil uVision project ble_app_pwr_profiling_s110_pca10028.uvprojx, settings and files
target nrf51822_5TM_s110 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT  BLE_DFU_APP_SUPPORT
  c misc: --c99
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c spi_master.c ble_bas.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51822_xxAA/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h device_manager_cnfg.h
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/ble_services/ble_hrs/: ble_hrs.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/ble_services/ble_dfu/: ble_dfu.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/device_manager/: device_manager_peripheral.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51822_xxAA/: simple_uart.c simple_uart.h pstorage.c pstorage.h pstorage_platform.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51822_xxAA/: app_error.c app_error.h app_fifo.c app_fifo.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h app_trace.h
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Libraries/1.1.0/bootloader_dfu/: bootloader_util_arm.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Libraries/1.1.0/bootloader_dfu/experimental/: dfu_app_handler.c
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51822_xxAA/: softdevice_handler.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.0, nRF_BLE:BLE_Modules:ble_common 1.1.0, nRF_BLE:BLE_Modules:ble_conn_params 1.1.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.0, nRF_BLE:BLE_Modules:device_manager 1.1.0, nRF_BLE:BLE_Services:ble_dfu 1.1.0, nRF_BLE:BLE_Services:ble_hrs 1.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:nrf_temp 1.2.0, nRF_Drivers:pstorage 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Libraries:DFU:dfu_app_handler 1.1.0, nRF_Libraries:DFU:dfu_bootloader_util 1.1.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_fifo 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_trace 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0, nRF_SoftDevice:Internal:sd_common 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s110 7.1.0-3
