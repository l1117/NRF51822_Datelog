# Keil uVision project ble_app_pwr_profiling_s110_pca10028 .uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c spi_master.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/2.0.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51422_xxAC/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
    RTE/nRF_BLE/nRF51822_xxAA/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/2.0.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: app_uart.h app_uart.c pstorage.c pstorage.h pstorage_platform.h simple_uart.c simple_uart.h
    RTE/nRF_Drivers/nRF51822_xxAA/: app_uart.h app_uart.c pstorage.c pstorage.h pstorage_platform.h simple_uart.c simple_uart.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_fifo.c app_fifo.h app_gpiote.c app_gpiote.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h app_scheduler.c app_scheduler.h
    RTE/nRF_Libraries/nRF51822_xxAA/: app_error.c app_error.h app_fifo.c app_fifo.h app_gpiote.c app_gpiote.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h app_scheduler.c app_scheduler.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAC/: s110_nrf51_8.0.0_licence-agreement.txt s110_softdevice.hex softdevice_handler.c
    RTE/nRF_SoftDevice/nRF51822_xxAA/: s110_nrf51_8.0.0_licence-agreement.txt s110_softdevice.hex softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.20.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Drivers:simple_uart 1.2.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s110 8.0.0, nRF_SoftDevice:s110_hex 8.0.0, nRF_SoftDevice:softdevice_hex 1.1.2
